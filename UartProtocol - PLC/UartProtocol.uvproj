# Keil uVision project UartProtocol.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UartProtocol +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./src/: startup_stm32f10x_md.s main.c uart.c uartprotocol.c in.c out.c sled.c pulse.c encode.c runner.c bytestream.c Timer.c FX1N.c flash.c
